# Keil uVision project Project.uvprojx, settings and files
target GD32F30X_HD (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\;..\A-CMSIS\GD32F30x\Include;..\B-DRIVER\Include;..\A-CMSIS;..\D-CONFIGURATION\GPIO;..\D-CONFIGURATION;..\D-CONFIGURATION\Communication;..\D-CONFIGURATION\TIME;..\D-CONFIGURATION\sys;..\E-APPLICATION
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group A-CMSIS
    ../A-CMSIS/GD32F30x/Source/: system_gd32f30x.c
    ../A-CMSIS/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group B-DRIVER
    ../B-DRIVER/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group C-MAIN
    ./: main.c gd32f30x_it.c systick.c
  group D-CONFIGURATION
    ../D-CONFIGURATION/GPIO/: GPIO.c
    ../D-CONFIGURATION/sys/: sys.c
    ../D-CONFIGURATION/TIME/: TIME_Management.c delay.c
    ../D-CONFIGURATION/Communication/: SPI.c usart.c SDIO.c
  group APPLICATION
    ../E-APPLICATION/: LED.c SD_Card.c LCD.c LCD_Display.c
